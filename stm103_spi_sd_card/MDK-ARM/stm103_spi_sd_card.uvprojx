# Keil uVision project stm103_spi_sd_card.uvprojx, settings and files
target stm103_spi_sd_card (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm103_spi_sd_card
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\FatFS\Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c gpio.c usart.c spi.c stm32f1xx_hal_msp.c printf.c usbd_desc.c usbd_conf.c rtc.c usb_device.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group FatFS
    ../FatFS/Src/: ccsbcs.c diskio.c fat_sd_spi.c ff.c syscall.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
software components: CMSIS:CORE 4.3.0
